# IAR project project.ewp, settings and files
configuration STM32F303xC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F303xC
  ICCARM.CCIncludePath2: ..\; ..\System; ..\STM32F30x_StdPeriph_Driver\inc; ..\Display; ..\SignalCapture; ..; ..\nvram
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: C:\!Crafts\Логический тестер\Firmware\System\stm32f303xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Display
    ../Display/: display_functions.c display_functions.h ST7735.c ST7735.h
  group NVRAM
    ../nvram/: nvram.c nvram.h stm32f3_flash.c stm32f3_flash.h
  group SignalCapture
    ../SignalCapture/: adc_controlling.c comparator_handling.c data_processing.c freq_measurement.c slow_scope.c slow_scope.h
  group STM32F30x_SPL
    ../STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_comp.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c
  group System
    ../System/: startup_stm32f303xc.s stm32f30x.h system_stm32f30x.c
  group User
    ../: config.h generator_timer.c hardware.c keys_controlling.c main.c menu_selector.c mode_controlling.c power_controlling.c stm32f30x_it.c
